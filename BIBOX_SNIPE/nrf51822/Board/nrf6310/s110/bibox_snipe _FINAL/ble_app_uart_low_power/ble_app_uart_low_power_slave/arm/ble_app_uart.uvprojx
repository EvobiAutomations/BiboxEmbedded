# Keil uVision project ble_app_uart.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_uart +hex
  c flags: Optim=1 uC99=1
  c define: BOARD_NRF6310 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s110;..\..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Source Code
    ./../: main.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../: ble_nus.c
  group Libraries
    ../../../../../../Source/ble/: ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../../Source/app_common/: app_timer.c app_gpiote.c app_fifo.c
    ../: app_uart_fifo_mod.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: ble_app_uart +hex
  c flags: Optim=1 uC99=1
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
