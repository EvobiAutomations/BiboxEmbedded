# Keil uVision project blinky.uvprojx, settings and files
target nrf51822_xxaa (256K) (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: blinky_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\arm;..\..\blinky_example
  memory RVCT4: ROM 0x16000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c ST7735.c winbond_flash.c
    ../../../../Source/: keil_arm_uv4.lnt
    ../../../../Source/simple_uart/: simple_uart.c
  group lib
    ../../../../Source/nrf_delay/: nrf_delay.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: blinky_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110 (256K) (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: blinky_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: blinky_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: blinky_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: blinky_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
