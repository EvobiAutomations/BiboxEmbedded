# Keil uVision project bibox_tern.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bibox_tern_3_1_8 +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s110;..\..\..\..\..\..\Include\sd_common;..\arm;C:\Keil_v5\ARM\Pack\NordicSemiconductor\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../: ble_nus.c
  group Libraries
    ../../../../../../Source/ble/: ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../../Source/app_common/: app_timer.c app_gpiote.c pstorage.c
    ./: nrf_pwm.c winbond_flash.c ST7735.c soft_spi.c max7219.c MFRC522.c mma8452.c mp3module.c twi.c timeslot.c apds9960.c bibox.c hmc5883.c lcd.c mpu6050.c twi_hw_master.c user.c
    ../../../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../../../Source/simple_uart/: simple_uart.c
  group debug
    C:/Keil_v5/ARM/Pack/NordicSemiconductor/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s110;..\..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
